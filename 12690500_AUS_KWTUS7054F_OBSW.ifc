Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 83bd05c9-6917-4c9e-8ba7-3f6790bde09c, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-15T00:13:24+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12690500_AUS_KWTUS7054F_OBSW:39705410_AUS_12690500_KWTUS7054F_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, Spruce, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Design_Cast, z_Miele_Connection_Connection_Modul, z_Miele_Design_Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 819 mm; Depth: 579 mm
Pset_BuildingElementProxyCommon - Reference: 39705410_AUS_12690500_KWTUS7054F_OBSW; sets with these values: 2
